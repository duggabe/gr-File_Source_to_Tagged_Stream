options:
  parameters:
    author: Barry Duggan
    description: Baseband stream packets
    generate_options: no_gui
    id: str_pkt_21
    output_language: python
    title: str_pkt_21
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: output.png
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: customEPB_FStTS_0
  id: customEPB_FStTS
  parameters:
    FileName: ./DCS_logo.png
    Pkt_len: '512'
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '''11100001010110101110100010010011'''
    tagname: packet_len
    threshold: '0'
    type: byte
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_crc32_bb_0_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: '"packet_len"'
  states: {}
- name: header_bits
  id: virtual_sink
  parameters:
    stream_id: Header Bytes
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: Payload Bytes
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: pkt_out
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: Header Bytes
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: Payload Bytes
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: pkt_out
  states: {}

connections:
- [blocks_repack_bits_bb_1, '0', virtual_sink_1, '0']
- [blocks_repack_bits_bb_1_0, '0', digital_crc32_bb_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_repack_bits_bb_1, '0']
- [blocks_throttle_0, '0', digital_crc32_bb_0, '0']
- [customEPB_FStTS_0, '0', blocks_throttle_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_1_0, '0']
- [digital_crc32_bb_0, '0', digital_protocol_formatter_bb_0, '0']
- [digital_crc32_bb_0, '0', virtual_sink_0_0, '0']
- [digital_crc32_bb_0_0, '0', blocks_file_sink_0, '0']
- [digital_protocol_formatter_bb_0, '0', header_bits, '0']
- [digital_protocol_formatter_bb_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, blocks_message_debug_0, print]
- [virtual_source_0, '0', blocks_tagged_stream_mux_0, '0']
- [virtual_source_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [virtual_source_1, '0', digital_correlate_access_code_xx_ts_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
